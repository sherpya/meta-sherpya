SUMMARY = "Simple generic functions (similar to Python's own len(), pickle.dump(), etc.)"

LICENSE = "ZPL-2.1"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/ZPL-2.1;md5=5166e505dd5e2073ab1f97b1a6b31755"

SRC_URI[md5sum] = "f9c1fab00fd981be588fc32759f474e3"
SRC_URI[sha256sum] = "dc972e06094b9af5b855b3df4a646395e43d1c9d0d39ed345b7393560d0b9173"

PYPI_PACKAGE_EXT = "zip"

inherit pypi allarch
