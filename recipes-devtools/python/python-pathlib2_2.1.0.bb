SUMMARY = "Object-oriented filesystem paths"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=98acde304cdd38e796f0f4e5e7d803d4"

SRC_URI[md5sum] = "38e4f58b4d69dfcb9edb49a54a8b28d2"
SRC_URI[sha256sum] = "deb3a960c1d55868dfbcac98432358b92ba89d95029cddd4040db1f27405055c"

inherit pypi allarch
