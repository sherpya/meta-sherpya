SUMMARY = "This module offers a simple interface to query NTP servers from Python."

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=54;endline=54;md5=c3f07aaf829a0fa3e19b2ed383f777ad"

SRC_URI[md5sum] = "c3474b95033dc79ffcd33bcf840aa8b0"
SRC_URI[sha256sum] = "9fc99f71b14641b31698e4ced3d5f974eec225bfbae089ebe44b5808ba890f71"

inherit pypi allarch
