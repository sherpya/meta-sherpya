SUMMARY = "IPv4/IPv6 manipulation library"

LICENSE = "PSFv2"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7f538584cc3407bf76042def7168548a"

SRC_URI[md5sum] = "8bbf0326719fafb1f453921ef96729fe"
SRC_URI[sha256sum] = "3a21c5a15f433710aaa26f1ae174b615973a25182006ae7f9c26de151cd51716"

inherit pypi allarch
