SUMMARY = "Pygments is a syntax highlighting package written in Python"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4aec35eaf03f2237e4dafea7a7ee1fa6"

SRC_URI[md5sum] = "ed3fba2467c8afcda4d317e4ef2c6150"
SRC_URI[sha256sum] = "88e4c8a91b2af5962bfa5ea2447ec6dd357018e86e94c7d14bd8cacbc5b55d81"

PYPI_PACKAGE = "Pygments"

inherit pypi allarch
