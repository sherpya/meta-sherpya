SUMMARY = "Internationalized Domain Names in Applications (IDNA)"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=134bdad79491c37bdae32811572b4bc6"

SRC_URI[md5sum] = "f6473caa9c5e0cc1ad3fd5d04c3c114b"
SRC_URI[sha256sum] = "ed36f281aebf3cd0797f163bb165d84c31507cedd15928b095b1675e2d04c676"

inherit pypi allarch
