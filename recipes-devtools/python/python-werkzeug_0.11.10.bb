SUMMARY = "The Swiss Army knife of Python web development"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a68f5361a2b2ca9fdf26b38aaecb6faa"

SRC_URI[md5sum] = "780967186f9157e88f2bfbfa6f07a893"
SRC_URI[sha256sum] = "cc64dafbacc716cdd42503cf6c44cb5a35576443d82f29f6829e5c49264aeeee"

PYPI_PACKAGE = "Werkzeug"

inherit pypi allarch
