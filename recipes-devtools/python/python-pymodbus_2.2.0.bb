SUMMARY = "A full modbus protocol written in python"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=10;endline=10;md5=e910b35b0ef4e1f665b9a75d6afb7709"

SRC_URI[md5sum] = "8842c91cfc5704f8208ce83d233ce947"
SRC_URI[sha256sum] = "f30bc17c5f0affb017215f28c04c669fcb9f2947a1e1da57984e4854c04cf852"

inherit pypi allarch
