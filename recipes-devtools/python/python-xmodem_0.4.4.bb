SUMMARY = "Portable network interface information"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=8227180126797a0148f94f483f3e1489"

SRC_URI[md5sum] = "570772c676cb346bde827960a465ef38"
SRC_URI[sha256sum] = "bbbacfd8a72ede2479bd87cce748d092a3e5142ce90c8c7c2106ddf4c91f68a1"

inherit pypi
