SUMMARY = "This module offers a simple interface to query NTP servers from Python."

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=54;endline=54;md5=c3f07aaf829a0fa3e19b2ed383f777ad"

SRC_URI[md5sum] = "c7cc8e9b09f40c84819859d70b7784ca"
SRC_URI[sha256sum] = "c4621b64d50be9461d9bd9a71ba0b4af06fbbf818bbd483752d95c1a4e273ede" 

inherit pypi 
