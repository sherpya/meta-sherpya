SUMMARY = "Implementation of Linux watchdog device API"

LICENSE = "Python-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Python-2.0;md5=a5c8025e305fb49e6d405769358851f6"

SRC_URI[md5sum] = "5913a2e9066865dfc78ce49d4a470d10"
SRC_URI[sha256sum] = "5666b79a08bccca16d3be0f6f0d6f37c0d020ed22dc9ba72304d878c62490967"

inherit pypi setuptools
