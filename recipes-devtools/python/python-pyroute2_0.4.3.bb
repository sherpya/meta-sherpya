SUMMARY = "A pure Python netlink and Linux network configuration library"

LICENSE = "GPLv3 & Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.Apache.v2;md5=34281e312165f843a2b7d1f114fe65ce"

SRC_URI[md5sum] = "cd909c265382ee2453f19953ffa26736"
SRC_URI[sha256sum] = "d8c663a946a51208bc89e6fd8b4454808b785590681e8e971465f47186e4a4d1"

inherit pypi allarch
